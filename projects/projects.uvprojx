# Keil uVision project projects.uvprojx, settings and files
target projects (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: projects +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,PY32F002Bx5
  c include: ..\libraries\cmsis\Include;..\libraries\cmsis\Device\PY32F0xx\Include;..\libraries\hal_driver\inc;..\app;..\board;..\board\arch;..\board\config;..\drivers;..\utility;..\components\log;..\components\ringbuffer;..\components\utils;..\board\ports\kservice
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group app
    ../app/: main.c
  group board
    ../board/: board.c hal_msp.c interrupt.c
  group board/arch
    ../board/arch/: system_py32f0xx.c startup_py32f002bxx_armcc.s
  group board/ports
    ../board/ports/kservice/: kservice-ports.c
  group components
    ../components/utils/: kservice.c kstdio.c utility.c
    ../components/log/: log.c
    ../components/ringbuffer/: ringbuffer.c
  group hal_drivers
    ../libraries/hal_driver/src/: py32f002b_hal.c py32f002b_hal_adc.c py32f002b_hal_cortex.c py32f002b_hal_crc.c py32f002b_hal_exti.c py32f002b_hal_flash.c py32f002b_hal_gpio.c py32f002b_hal_i2c.c py32f002b_hal_iwdg.c py32f002b_hal_lptim.c py32f002b_hal_pwr.c py32f002b_hal_rcc.c py32f002b_hal_rcc_ex.c py32f002b_hal_spi.c py32f002b_hal_tim.c py32f002b_hal_tim_ex.c py32f002b_hal_uart.c py32f002b_hal_usart.c py32f002b_ll_adc.c py32f002b_ll_comp.c py32f002b_ll_crc.c py32f002b_ll_exti.c py32f002b_ll_gpio.c py32f002b_ll_i2c.c py32f002b_ll_lptim.c py32f002b_ll_pwr.c py32f002b_ll_rcc.c py32f002b_ll_spi.c py32f002b_ll_tim.c py32f002b_ll_usart.c py32f002b_ll_utils.c py32f002b_hal_comp.c
